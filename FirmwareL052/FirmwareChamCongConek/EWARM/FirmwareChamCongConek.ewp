# IAR project FirmwareChamCongConek.ewp, settings and files
configuration FirmwareChamCongConek (ARM, debug)
  General.OGChipSelectEditMenu: STM32L052K8 ST STM32L052K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L052xx; USE_TINZ
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\DucaLib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FirmwareChamCongConek.hex
  ILINK.IlinkOutputFile: FirmwareChamCongConek.out
  ILINK.IlinkIcfFile: stm32l052xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/DucaLib/inc
    ../DucaLib/inc/: bcdencode.h debug_uart.h ndef.h nfcm1833_module.h nfcm1833tiny.h nfcm1833tinz.h
  group Application/DucaLib/src
    ../DucaLib/src/: bcdencode.c debug_uart.c ndef.c nfcm1833_module.c nfcm1833tiny.c nfcm1833tinz.c
  group Application/EWARM
    ./: startup_stm32l052xx.s
  group Application/User
    ../Src/: Config.c Fonts.c main.c SSD1306.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
